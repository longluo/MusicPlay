# Keil uVision project MusicPlay.uvproj, settings and files
target MusicPlay (ARM-ADS)
  device: LM3S8962 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MusicPlay +hex
  c flags: Optim=1
  c include: ..\..\Source\HAL\Oled\Head;..\..\Source\HAL\IO\Head;..\..\Source\App\Head;..\..\Source\LM3S_Lib\inc;..\..\Source\HAL\Key\Head
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../../Source/App/Src/: Main.c
  group HAL
    ../../Source/HAL/: Startup_rvmdk.s
    ../../Source/HAL/Oled/Src/: rit128x96x4.c
    ../../Source/HAL/IO/Src/: Io.c
  group LM3S_Drv_Lib
    ../../Source/LM3S_Lib/DriverLib/: driverlib.lib
